# Repository torsteinnh/DTimponator-badge

File README.md:

# Om designet

Designet tar utgangspunkt i imponatoren til Hackerspace NTNU. Den er laget for å tilby en imponator bestående av kun en enhet med fokus på en bakside uten skarpe pigger som kan rive opp klær.

# Om produksjon
Det er anbefalt å først montere alle SMD-komponenter på baksiden med loddeovd, så feste SMD-komponentene på forsiden med varmluft eller bold, deretter TH-komponentene og til sist klesnåla.
Videre er det anbefalt å ikke montere headerpinnene til programmereren, men heller bruke en fjærnålkontakt til programmeringen.

## KiCad design DTimponator-badge.kicad_pcb

Parts:
BT1: Battery_Cell; BatteryHolder_Multicomp_BC-2001_1x2032
C1: .1uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: AVR-ISP; PinHeader_2x03_P2.54mm_Horizontal
R1, R2, R3, R4, R5, R6, R7, R8, R10, R11, R12, R13, R14, R15, R16, R17: 220; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R9: 10k; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
SW1: SW_SPDT; SW_E-Switch_EG1224_SPDT_Angled
U1, U3: 74HC595; TSSOP-16_4.4x5mm_P0.65mm
U2: ATtiny85-20S; SOIC-8W_5.3x5.3mm_P1.27mm

Connections:
/MISO: J1.1 (MISO), U1.12 (RCLK), U2.6 (PB1), U3.12 (RCLK)
/MOSI: J1.4 (MOSI), R9.2, U2.5 (AREF/PB0)
/SCK: J1.3 (SCK), U1.11 (SRCLK), U2.7 (PB2), U3.11 (SRCLK)
/SER: U1.14 (SER), U2.2 (XTAL1/PB3)
/~OE_PWM: U1.13 (~OE), U2.3 (XTAL2/PB4), U3.13 (~OE)
/~RST: J1.5 (~RST), U2.1 (~RESET/PB5)
GND: BT1.2 (-), C1.2, J1.6 (GND), R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, U1.8 (GND), U2.4 (GND), U3.8 (GND)
unnamed: BT1.1 (+), SW1.2 (B)
unnamed: D1.2 (A), U1.15 (QA)
unnamed: D1.1 (K), R1.1
unnamed: D2.2 (A), U1.1 (QB)
unnamed: D2.1 (K), R2.1
unnamed: D3.2 (A), U1.2 (QC)
unnamed: D3.1 (K), R3.1
unnamed: D4.2 (A), U1.3 (QD)
unnamed: D4.1 (K), R4.1
unnamed: D5.2 (A), U1.4 (QE)
unnamed: D5.1 (K), R5.1
unnamed: D6.2 (A), U1.5 (QF)
unnamed: D6.1 (K), R6.1
unnamed: D7.2 (A), U1.6 (QG)
unnamed: D7.1 (K), R7.1
unnamed: D8.2 (A), U1.7 (QH)
unnamed: D8.1 (K), R8.1
unnamed: D9.2 (A), U3.15 (QA)
unnamed: D9.1 (K), R10.1
unnamed: D10.2 (A), U3.1 (QB)
unnamed: D10.1 (K), R11.1
unnamed: D11.2 (A), U3.2 (QC)
unnamed: D11.1 (K), R12.1
unnamed: D12.2 (A), U3.3 (QD)
unnamed: D12.1 (K), R13.1
unnamed: D13.2 (A), U3.4 (QE)
unnamed: D13.1 (K), R14.1
unnamed: D14.2 (A), U3.5 (QF)
unnamed: D14.1 (K), R15.1
unnamed: D15.2 (A), U3.6 (QG)
unnamed: D15.1 (K), R16.1
unnamed: D16.2 (A), U3.7 (QH)
unnamed: D16.1 (K), R17.1
unnamed: U1.9 (QH'), U3.14 (SER)
VCC: C1.1, J1.2 (VCC), R9.1, SW1.3 (C), U1.10 (~SRCLR), U1.16 (VCC), U2.8 (VCC), U3.10 (~SRCLR), U3.16 (VCC)

Board: 2 copper layers, 52.0 x 52.0 mm, 40 parts (24 on the bottom side), 42 nets.

## KiCad design CogLightBadgeTHT.kicad_pcb

Parts:
BT1: Battery_Cell; MP000362_CR2032_Holder_THT
C1: .1uF; C_Disc_D5.0mm_W2.5mm_P5.00mm
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16: LED; LED_D5.0mm
J1: AVR-ISP; IDC-Header_2x03_P2.54mm_Vertical
R1, R2, R3, R4: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R5, R6: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
SW1: SW_SPDT; OS102011MA1QN1_SPDT_SlideSwithch_THT
SW2, SW3: SW_Push; SW_PUSH_6mm_H5mm
U1: ATtiny84A-PU; DIP-14_W7.62mm_LongPads

Connections:
/sink1: D1.1 (K), D5.1 (K), D9.1 (K), D13.1 (K), J1.3 (SCK), U1.9 (PA4)
/sink2: D2.1 (K), D6.1 (K), D10.1 (K), D14.1 (K), J1.1 (MISO), U1.8 (PA5)
/sink3: D3.1 (K), D7.1 (K), D11.1 (K), D15.1 (K), J1.4 (MOSI), U1.7 (PA6)
/sink4: D4.1 (K), D8.1 (K), D12.1 (K), D16.1 (K), U1.6 (PA7)
/source1: R1.2, U1.13 (AREF/PA0)
/source2: R2.2, U1.12 (PA1)
/source3: R3.2, U1.11 (PA2)
/source4: R4.2, U1.10 (PA3)
GND: BT1.2 (-), C1.2, J1.6 (GND), SW2.2, SW3.2, U1.14 (GND)
unnamed: BT1.1 (+), SW1.2 (B)
unnamed: D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), R1.1
unnamed: D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), R2.1
unnamed: D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), R3.1
unnamed: D13.2 (A), D14.2 (A), D15.2 (A), D16.2 (A), R4.1
unnamed: J1.5 (~RST), U1.4 (~RESET~/PB3)
unnamed: R5.2, SW2.1, U1.5 (PB2)
unnamed: R6.2, SW3.1, U1.3 (XTAL2/PB1)
VCC: C1.1, J1.2 (VCC), R5.1, R6.1, SW1.3 (C), U1.1 (VCC)

Board: 2 copper layers, 71.0 x 99.5 mm, 29 parts (2 on the bottom side), 18 nets.

## Commit log

2020-11-28 First commit, board is oversized.
2021-02-25 Downsized pcb and component layout
2021-02-25 Trace routing
2021-02-25 Removing ignored files
2021-02-25 Improved siklscreen layout
2021-02-26 Removing sharp angles connecting angled square pads
2021-03-10 Remove tem file
2021-03-10 Changing LED resistors to 330 ohm
2021-10-14 Add polarity markings for the LEDs
2022-01-13 Updated metadata, footprints and KiCad version
2022-01-13 Changed much to SMD
2022-01-23 Changed to dimmable SMD LEDs
2022-01-24 Changed from led matrix to led array for increased brightness, routed pcb.
2022-02-11 Finished routing, generated gerger files
2022-02-12 Added simple program for the badge
2023-12-12 Made V2
